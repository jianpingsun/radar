# IAR project Backup of radar_test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407IG ST STM32F407IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40_41xxx; ARM_MATH_CM4; USE_USB_OTG_HS; USE_ULPI_PHY
  ICCARM.CCIncludePath2: ..\core; ..\FWlib\inc; ..\startup; ..\DSP_Lib\lib; ..\DSP_Lib\source\BasicMathFunctions; ..\DSP_Lib\source\ComplexMathFunctions; ..\DSP_Lib\source\FastMathFunctions; ..\DSP_Lib\source\TransformFunctions; ..\lwIP; ..\lwIP\conf; ..\lwIP\src\include; ..\lwIP\src\include\lwip; ..\lwIP\src\include\ipv4; ..\lwIP\netconf\; ..\lwIP\src; ..\lwIP\src\netif; ..\lwIP\src\core\ipv4; ..\Libraries\class\cdc\inc; ..\Libraries\core\inc; ..\Libraries\drivers\inc; ..\ucos\config; ..\ucos\core; ..\ucos\port; ..\user; ..\user\segger; ..\user\main; ..\user\ADC; ..\user\APP; ..\user\waveform; ..\user\USB; ..\user\ETH_Driver; ..\user\FIFO; ..\user\transfer
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: radar_test.hex
  ILINK.IlinkOutputFile: radar_test.out
  ILINK.IlinkIcfFile: E:\projects\Software\radar_test\project\radar_test.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group core
    ../core/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group DSP_Lib/lib
    ../DSP_Lib/lib/: iar_cortexM4lf_math.a
  group DSP_Lib/source/BasicMathFunctions
    ../DSP_Lib/source/BasicMathFunctions/: arm_abs_f32.c arm_abs_q15.c arm_abs_q31.c arm_abs_q7.c arm_add_f32.c arm_add_q15.c arm_add_q31.c arm_add_q7.c arm_dot_prod_f32.c arm_dot_prod_q15.c arm_dot_prod_q31.c arm_dot_prod_q7.c arm_mult_f32.c arm_mult_q15.c arm_mult_q31.c arm_mult_q7.c arm_negate_f32.c arm_negate_q15.c arm_negate_q31.c arm_negate_q7.c arm_offset_f32.c arm_offset_q15.c arm_offset_q31.c arm_offset_q7.c arm_scale_f32.c arm_scale_q15.c arm_scale_q31.c arm_scale_q7.c arm_shift_q15.c arm_shift_q31.c arm_shift_q7.c arm_sub_f32.c arm_sub_q15.c arm_sub_q31.c arm_sub_q7.c
  group DSP_Lib/source/ComplexMathFunctions
    ../DSP_Lib/source/ComplexMathFunctions/: arm_cmplx_conj_f32.c arm_cmplx_conj_q15.c arm_cmplx_conj_q31.c arm_cmplx_dot_prod_f32.c arm_cmplx_dot_prod_q15.c arm_cmplx_dot_prod_q31.c arm_cmplx_mag_f32.c arm_cmplx_mag_q15.c arm_cmplx_mag_q31.c arm_cmplx_mag_squared_f32.c arm_cmplx_mag_squared_q15.c arm_cmplx_mag_squared_q31.c arm_cmplx_mult_cmplx_f32.c arm_cmplx_mult_cmplx_q15.c arm_cmplx_mult_cmplx_q31.c arm_cmplx_mult_real_f32.c arm_cmplx_mult_real_q15.c arm_cmplx_mult_real_q31.c
  group DSP_Lib/source/FastMathFunctions
    ../DSP_Lib/source/FastMathFunctions/: arm_cos_f32.c arm_cos_q15.c arm_cos_q31.c arm_sin_f32.c arm_sin_q15.c arm_sin_q31.c arm_sqrt_q15.c arm_sqrt_q31.c
  group DSP_Lib/source/TransformFunctions
    ../DSP_Lib/source/TransformFunctions/: arm_bitreversal.c arm_bitreversal2.S arm_cfft_f32.c arm_cfft_q15.c arm_cfft_q31.c arm_cfft_radix2_f32.c arm_cfft_radix2_init_f32.c arm_cfft_radix2_init_q15.c arm_cfft_radix2_init_q31.c arm_cfft_radix2_q15.c arm_cfft_radix2_q31.c arm_cfft_radix4_f32.c arm_cfft_radix4_init_f32.c arm_cfft_radix4_init_q15.c arm_cfft_radix4_init_q31.c arm_cfft_radix4_q15.c arm_cfft_radix4_q31.c arm_cfft_radix8_f32.c arm_dct4_f32.c arm_dct4_init_f32.c arm_dct4_init_q15.c arm_dct4_init_q31.c arm_dct4_q15.c arm_dct4_q31.c arm_rfft_f32.c arm_rfft_fast_f32.c arm_rfft_fast_init_f32.c arm_rfft_init_f32.c arm_rfft_init_q15.c arm_rfft_init_q31.c arm_rfft_q15.c arm_rfft_q31.c
  group FWlib/inc
    ../FWlib/inc/: misc.h stm32f4xx_adc.h stm32f4xx_dac.h stm32f4xx_dma.h stm32f4xx_gpio.h stm32f4xx_rcc.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h
  group FWlib/src
    ../FWlib/src/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group lwIP/arch
    ../lwIP/arch/: cc.h cpu.h perf.h
  group lwIP/conf
    ../lwIP/conf/: lwipopts.h
  group lwIP/netconf
    ../lwIP/netconf/: netconf.c netconf.h
  group lwIP/src/api
    ../lwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwIP/src/core
    ../lwIP/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../lwIP/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group lwIP/src/netif
    ../lwIP/src/netif/: etharp.c ethernetif.c ethernetif.h
  group startup
    ../startup/: startup_stm32f40_41xxx.s
  group ucos/config
    ../ucos/config/: includes.h os_cfg.h
  group ucos/core
    ../ucos/core/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group ucos/port
    ../ucos/port/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group USB Device/Class/CDC
    ../Libraries/Class/cdc/src/: usbd_cdc_core.c
  group USB Device/Libraries
    ../Libraries/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group USB Drivers
    ../Libraries/Drivers/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group user
    ../user/: conf.h stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.c system_stm32f4xx.c system_stm32f4xx.h
  group user/ADC
    ../user/ADC/: ADC.c ADC.h
  group user/APP
    ../user/APP/: APP.c APP.h
  group user/ETH_Driver
    ../user/ETH_Driver/: stm32f4x7_eth.c stm32f4x7_eth.h stm32f4x7_eth_bsp.c stm32f4x7_eth_bsp.h stm32f4x7_eth_conf.h
  group user/FIFO
    ../user/FIFO/: FIFO.c FIFO.h
  group user/main
    ../user/main/: main.c main.h
  group user/segger
    ../user/segger/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group user/transfer
    ../user/transfer/: transfer.c transfer.h transfer_eth.c transfer_eth.h transfer_usb.c transfer_usb.h
  group user/USB
    ../user/USB/: usb_bsp.c usb_conf.h usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
  group user/waveform
    ../user/waveform/: waveform.c waveform.h
